Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: Project Number
Time: 2022-10-06T10:32:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.5.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 06 10:32:54 2022 * Host: HPZ2-TPLAT * Database: C:\Users\TESSAP~1\AppData\Local\Temp\{366EDDE8-3970-42BB-B2C3-EC2D650C93B3}\ifc * Database version: 5507 * Database creation date: Thu Oct 06 10:32:54 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 06 10:32:54 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 06 10:32:54 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - BCB_ProjectFolder: C:\Users\Tessa Plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\6. Bevestigen, hijsen en monteren\1240_Staafanker 3010; Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; BCB_ProjectFolder: C:\Users\Tessa Plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\6. Bevestigen, hijsen en monteren\1240_Staafanker 3010; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Circle Head - Project Datum
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other - Category: Levels; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcBuildingElementProxy: NLRSnl_0-.21_GM_WPB_1240-Staafanker-Rod connector 3010_Mavotrans_R19:124004_Ø25/M30-1055, 124004
In: Level 0
Type - Material: Stainless Steel AISI 304
Type - Constraints - Default Elevation: 1219.2 mm
Type - Dimensions - a (mm): 60 mm; d_nom: M30; I (mm): 90 mm; L (mm): 1055 mm; Lengtetolerantie | Tolerance of length (mm): +0/-20; Ø (mm): 25 mm
Type - Fire Protection - Brandwerendheid | Fire resistance rating: Niet getest | Not rated
Type - Identity Data - Artikelnummer | Article number: 124004; Beschrijving | Description: Staafanker | Rod anchor M30; Certificaten | Certification: Eurocode 2; Laatste versie | Last version: 06-10-2022; Leverancier | Supplier: Mavotrans; Model: LOD400; NL-SfB code: 0-.21; Revisie | Revision: Rev0; Technische data | Technical data: Raadpleeg de gekoppelde webpagina | Please refer to linked URL; Tekenaar | Draftsman: D. Blokland; Type Name: 124004_Ø25/M30-1055; URL: https://mavotrans.nl/demu-staafanker-3010-rvs.html; Verpakkingshoeveelheid | Sales packaging: Verpakt per stuk | Sold per piece; Voorwaarden | Disclaimer: Raadpleeg de gekoppelde webpagina en controleer voor gebruik van dit BIM-model op de laatst beschikbare revisie. De modellen, geometrie, data en parameterwaarden zijn met de grootste zorg bepaald. Desalniettemin bestaat de mogelijkheid op onjuistheden. Elke aansprakelijkheid hiervoor wordt van de hand gewezen, hoewel melding op prijs wordt gesteld. © Mavotrans, 2022 | Please refer to linked URL and check for the latest available model revision. The models, geometry and parameter values have been determined with the greatest care. Still, they are subject to errors. Mavotrans cannot be held liable in any way. However, we do appreciate your feedback. © Mavotrans, 2022
Type - Materials and Finishes - Materiaal | Material: Wapeningsstaaf B500B (onbehandeld) met schroefdraad en RVS A4-80 draadbus | Rebar, stainless steel B500B with RVS A4-80
Type - Other - Category: Generic Models; a: 60 mm; Diameter: 25 mm; Family Name: NLRSnl_0-.21_GM_WPB_1240-Staafanker-Rod connector 3010_Mavotrans_R19; I: 90 mm; Length: 1055 mm
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_ProvisionForVoid - Diameter: 25 mm
Description: Staafanker | Rod anchor M30; Classification: 0-.21 (Default Classification); Material: Stainless Steel AISI 304, Rebar, ASTM A615, Grade 40
Pset_BuildingElementProxyCommon - Reference: NLRSnl_0-.21_GM_WPB_1240-Staafanker-Rod connector 3010_Mavotrans_R19:124004_Ø25/M30-1055; sets with these values: 2
Constraints - Level: Level: Level 0; Offset: 100 mm; Work Plane: Level : Level 0
Dimensions - Area: 0.050896 m2; Volume: 0.000525542 m3
Other - Family: NLRSnl_0-.21_GM_WPB_1240-Staafanker-Rod connector 3010_Mavotrans_R19: 124004_Ø25/M30-1055; Family and Type: NLRSnl_0-.21_GM_WPB_1240-Staafanker-Rod connector 3010_Mavotrans_R19: 124004_Ø25/M30-1055; L1: 995 mm; L2: 30 mm; Schedule Level: Level: Level 0; Type: NLRSnl_0-.21_GM_WPB_1240-Staafanker-Rod connector 3010_Mavotrans_R19: 124004_Ø25/M30-1055; Type Id: NLRSnl_0-.21_GM_WPB_1240-Staafanker-Rod connector 3010_Mavotrans_R19: 124004_Ø25/M30-1055
Phasing - Phase Created: New Construction
